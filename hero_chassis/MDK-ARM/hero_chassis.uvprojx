# Keil uVision project hero_chassis.uvprojx, settings and files
target hero_chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: hero_chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/vofa;../Drivers/Motor;../Drivers/PID;../Drivers/UART_IDLE;../Drivers/Referee_system;../Drivers/RC;../Drivers/chassis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/vofa/: vofa.c
    ../Drivers/UART_IDLE/: uartidle.c
    ../Drivers/PID/: PID.c
    ../Drivers/Motor/: motor.c
    ../Drivers/Referee_system/: Referee_system.c
    ../Drivers/RC/: rc.c
    ../Drivers/chassis/: chassis.c
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
